# Keil uVision project sosna_u_pr.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S8253 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: sosna_u_pr +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 SOSNA_U_PR.C IOMODULE.C GLOBAL_VAR.C BIOS.C
